# Autodesk Inventor assembly: 21.1731 FOOT 45 GD
## iProperties
Created: 2007-04
Part Number: 21.1731 FOOT 45 GD
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
